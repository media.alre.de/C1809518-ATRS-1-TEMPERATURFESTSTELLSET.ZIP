Properties of the parts of a building model (IFC2X3)

# File
Description: Temperatur-Feststellungsset für Anlegetemperaturregler ATR mit Außeneinstellung, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: C1809518, Temperatur-Feststellungsset für Anlegetemperaturregler ATR mit Außeneinstellung
In: Raum
Description: Mit dem Temperatur-Feststellungsset für die Anlegetemperaturregler ATR mit Außeneinstellung kann die Verstellung des eingestellten Sollwertes verhindert werden.; Classification: EC001231 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: C1809518; ModelLabel: ATRS-1; GlobalTradeItemNumber: 4050528018472; ProductURL: https://alre.de/produkt_C1809518
Pset_Specification - NominalLength: 0.025 m; NominalWidth: 0.014 m; NominalDepth: 0.001 m; NetWeight: 0.003
Pset_ALRE_ETIM_Properties - Ausführung: sonstige; Länge: 14; ETIM-Klasse: EC001231; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-C1809518.pdf
